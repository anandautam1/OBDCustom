# Keil uVision project OBD-II_Emulator.uvprojx, settings and files
target STM32F1 ROM (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_Host_No_Library
  c flags: Optim=1
  c define: STM32F4XX USE_STDPERIPH_DRIVER USE_STM32F4_DISCOVER USE_USB_OTG_FS
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./src/: main.cpp stm32f10x_it.c utility.cpp GPIOController.cpp RCCController.cpp DispCode.cpp
  group Headers
    ./inc/: stm32f10x_it.h stm32f10x_conf.h gpioRegisters.h rccRegisters.h GPIOController.h canRegisters.h RCCController.h adcRegisters.h utility.h DispCode.h Font_24x16.h stm32f10x_cl.h system_stm32f10x_cl.h
target STM32F1 RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: OBD-II_Emulator
  c flags: Optim=1
  c define: VECT_TAB_SRAM STM32F10X_CL
  c include: .\inc
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
